Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: PCC 27_1035.ifc
Time: 2023-12-05T09:39:37
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0.209.92 Dec 12 2020
Made in: Allplan 2022.1 28.09.2023 - 19:04:11

# IfcBuildingElementProxy, Podpora słupowa PCC 27/1035
In: PFEIFER
Material: B500B
AllplanAttributes - Numer pozycji: 0; Typ_robót: Roboty betonowe; Nazwa obiektu: PCC 27/1035; Nazwa: Podpora słupowa PCC 27/1035; Materiał: B500B; ID_komponentu_Allright: 0520ErE0000000517; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
