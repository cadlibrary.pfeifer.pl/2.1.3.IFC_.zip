Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: PCC 39-1_1690.ifc
Time: 2023-12-05T09:43:05
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0.209.92 Dec 12 2020
Made in: Allplan 2022.1 28.09.2023 - 19:04:11

# IfcBuildingElementProxy, Podpora słupowa PCC 39-1/1690
In: PFEIFER
Material: B500B
AllplanAttributes - Poziom_Dolny: 0 m; Poziom_Górny: 0 m; Typ_robót: Roboty betonowe; V6: 0 m; V7: 0 m; V8: 0 m; V9: 0; Nazwa obiektu: PCC 39-1/1690; Nazwa: Podpora słupowa PCC 39-1/1690; Materiał: B500B; ID_komponentu_Allright: 0520Mak0000001021; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
