Properties of the parts of a building model (IFC2X3)

# File
Description: no view
File name: PCC 20_910.ifc
Time: 2023-12-05T09:37:57
Author: Aleksander Skuła
Organization: No Organization
Written by: EDMsix Version 2.0.209.92 Dec 12 2020
Made in: Allplan 2022.1 28.09.2023 - 19:04:11

# IfcBuildingElementProxy, Podpora słupowa PCC 20/910
In: PFEIFER
Material: B500B
AllplanAttributes - Numer pozycji: 0; Typ_robót: Roboty betonowe; Nazwa obiektu: PCC 20/910; Nazwa: Podpora słupowa PCC 20/910; Materiał: B500B; ID_komponentu_Allright: 0520ErE0000000197; Jednostka: Szt
Pset_ManufacturerTypeInformation - Manufacturer: PFEIFER
